# Keil uVision project Car_stm32.uvprojx, settings and files
target Car_stm32 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Car_stm32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware/LED;../Hardware/MOTOR;../Hardware/MPU6050;../Hardware/PID;../Hardware/SERVO;../Hardware/USART;../Hardware/HC-SR04;../Hardware/Avoidance;../Hardware/Track;../Hardware/OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/MOTOR/: motor.c motor.h
    ../Hardware/MPU6050/: mpu6050.c mpu6050.h mpu6050_angle.c mpu6050_angle.h
    ../Hardware/PID/: pid.c pid.h
    ../Hardware/SERVO/: servo.c servo.h
    ../Hardware/LED/: led.c led.h
    ../Hardware/USART/: my_usart.c my_usart.h
    ../Hardware/HC-SR04/: hc_sr04.c hc_sr04.h
    ../Hardware/Avoidance/: avoidance.c avoidance.h
    ../Hardware/Track/: track.c track.h
    ../Hardware/OLED/: oled.c oled.h
software components: CMSIS:CORE 5.6.0
